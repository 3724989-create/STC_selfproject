# Keil uVision project TestLCD7735.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: TestLCD7735 +hex
  group USER
    ./USER/: Main.C LCD_7735.C
