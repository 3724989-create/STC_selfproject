# Keil uVision project FreeRTOS_STC32G12K.uvproj, settings and files
target FreeRTOS_STC32G_Demo (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: FreeRTOS_STC32G12K +hex
  link misc: REMOVEUNUSED
  group FreeRTOS_V10.5.1
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group port
    ./FreeRTOS/portable/STC32G12K128/: portmacro.h os_pendsv_config.h port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group library
    ./library/: STC32G_Delay.c STC32G_Clock.c
  group drive
    ./: UART1.C
  group app
    ./: START251.A51 main.c StatisticalOs.c isr.asm
  group task
    ./: StarTask.c
  group 使用说明
    ./: 使用说明.txt
