# Keil uVision project TestILI9341.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: TestLIL9341 +hex
  link misc: REMOVEUNUSED
  group USER
    ./USER/: Main.C LCD9341.C STC32G_SYS.C ISR.asm
