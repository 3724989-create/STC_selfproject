# Keil uVision project LQ_AI8051U_32Bit_LIB.uvproj, settings and files
target AI8051_32bit (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: LQ_STCAI32_LIB +hex
  link misc: REMOVEUNUSED
  group User
    ../User/: main.c config.h include.h STC_AI8051U_X.h
    ../Driver/: AI8051U_32_MDU32.LIB AI8051U_32_TFPU.LIB
  group APP
    ../LQ_LIB/Src/: LQ_GPIO.c LQ_WDT.c LQ_GPIO_LED.c LQ_KEY.c LQ_OLED096.c LQ_ADC.c LQ_TIMER.c LQ_UART.c LQ_XINT.c LQ_MotorServo.c LQ_Hard_I2C.c LQ_Soft_I2C.c LQ_Soft_SPI.c LQ_LSM6DSR.c LQ_I2C_VL53.c LQ_Encoder.c LQ_CCD.c LQ_EEPROM.c LQ_BDGPS.c LQ_UTM.c LQ_SBUS.c
  group ISR
    ../Driver/isr/: AI8051U_ADC_Isr.c AI8051U_DMA_Isr.c AI8051U_Exti_Isr.c AI8051U_GPIO_Isr.c AI8051U_I2C_Isr.c AI8051U_PWM_Isr.c AI8051U_RTC_Isr.c AI8051U_SPI_Isr.c AI8051U_Timer_Isr.c AI8051U_UART_Isr.c
  group Driver
    ../Driver/Src/: AI8051U_ADC.c AI8051U_Clock.c AI8051U_Compare.c AI8051U_Delay.c AI8051U_DMA.c AI8051U_EEPROM.c AI8051U_Exti.c AI8051U_GPIO.c AI8051U_I2C.c AI8051U_NVIC.c AI8051U_PWM.c AI8051U_RTC.c AI8051U_Soft_I2C.c AI8051U_Soft_UART.c AI8051U_SPI.c AI8051U_Timer.c AI8051U_UART.c AI8051U_WDT.c
  group Readme
    ../User/: Readme.txt
target STC32G (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: LQ_STCAI32_LIB +hex
  link misc: REMOVEUNUSED
